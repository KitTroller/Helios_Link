options:
  parameters:
    author: andreasodontopoulos
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.5'
    stop: '49'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: squelch_thresh
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '1'
    stop: '-10'
    value: '-30'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch_thresh
    type: float
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: '200000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '150000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '25000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '96800000'
    fftsize: '1024'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '96800000'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '6'
    type: fff
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: '96800000'
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
