options:
  parameters:
    author: andreasodontopoulos
    generate_options: qt_gui
    id: helios_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: '6500'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '867904600'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '5157'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: 50000/1199.5
  states: {}
- name: transition
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.01'
    gate: 'True'
    ramp: '0'
    threshold: '-36'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/(2*math.pi*fsk_deviation_hz))/20
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/(2*math.pi*fsk_deviation_hz))/20
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/andreasodontopoulos/SDR_recordings/helios_iq_1M.cfile
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '11010011100100011101001110010001'
    tagname: sync
    threshold: '0'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import numpy as np
      import pmt
      from gnuradio import gr
      import struct

      def pn9(n):
          state = 0b111111111
          out = []
          for _ in range(n):
              out.append(state & 0xFF)
              for _ in range(8):
                  feed_back_bit = ((state >> 5) ^ (state)) & 1
                  state = (state >> 1) | (feed_back_bit << 8)
          return out


      def crc_16(data):
          crc = 0xFFFF
          crc_polynomial = 0x8005
          for byte in data:
              for _ in range(8):
                  if(((crc & 0x8000) >> 8)  ^ (byte & 0x80)):
                      crc = (crc << 1) ^ crc_polynomial
                  else:
                      crc = crc << 1
                  
                  crc = crc & 0xFFFF
                  byte = (byte << 1) & 0xFF
          return crc



      class blk(gr.sync_block):
          def __init__(self, tag_name="sync"):           # shows up as a parameter in GRC
              gr.sync_block.__init__(self, name="HeliosLink deframer", in_sig=[np.uint8], out_sig=None)
              self.tag_name = tag_name
              self.white = pn9(64)                # PN9 table, made once
              self.collecting = False
              self.bits = []                   # bits of the packet being collected
              self.need = 0                    # total bits this packet has
              self.last_id = None
              self.good = 0
              self.lost = 0

          def work(self, input_items, output_items):
              bits = input_items[0]
              start = self.nitems_read(0)
              tag_pos = set()
              for tag in self.get_tags_in_window(0, 0, len(bits)):
                  if pmt.symbol_to_string(tag.key) == self.tag_name:
                      tag_pos.add(tag.offset - start)

              for i in range(len(bits)):
                  if not self.collecting:
                      if i not in tag_pos:
                          continue  # keep waiting (IDLE)
                      self.collecting = True
                      self.bits = []
                      self.need = 0
                  self.bits.append(int(bits[i]))
                  if len(self.bits) == 8:
                      L = int(np.packbits(self.bits)[0]) ^ self.white[0]  # packs into bytes
                      if ((L < 2) or (L > 61)):  # impossible length it was a false sync buffer is 64 bytes in cc1101 61 + 1 itself + RSSI and LQI/CRC_OK = 64
                          self.collecting = False
                          self.bits = []
                          self.need = 0
                          continue
                      self.need = (1 + L + 2) * 8  # length byte + L + 2 CRC, in bits
                  if len(self.bits) == self.need:
                      self.handle_packet()
                      self.collecting = False
                      self.bits = []
                      self.need = 0
              return len(bits)

          def handle_packet(self):
              raw = np.packbits(self.bits).tolist()
              white = self.white
              dewhitened_bits = [r ^ w for r, w in zip(raw, white)]
              Length = dewhitened_bits[0]
              crc_rx = dewhitened_bits[Length + 1] << 8 | dewhitened_bits[Length + 2]  # the 2 received CRC bytes as one 16-bit number, length does not count itself so indexing is correct
              if (crc_16(dewhitened_bits[:Length + 1]) ^ crc_rx):
                  print("CRC FAIL")
                  return
              self.good += 1
              pid, cmd = dewhitened_bits[1], dewhitened_bits[2]
              if self.last_id is not None:
                  self.lost += (pid - self.last_id - 1) & 0xFF
              self.last_id = pid
              payload = dewhitened_bits[3:Length + 1] # voltage_mv, temp_c10, uptime_s from d[3 : L+1]
              v, t, up = struct.unpack("<HhI", bytes(payload))
              print(f"id={pid} cmd={cmd} V={v} mV T={t/10:.1f} C up={up} s lost={self.lost}", flush=True)
    tag_name: '''sync'''
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '340'
    decim: '20'
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1, samp_rate, cutoff, transition)'
    type: ccc
  states: {}
- name: qtgui_eye_sink_x_1
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: '40'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/20
    fc: '0'
    fftsize: '2048'
    name: '"FSK 867.905Mhz"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"FSK 867.905Mhz"'
    size: '1024'
    srate: samp_rate/20
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Demodulated FSK"'
    nconnections: '2'
    size: '2048'
    srate: samp_rate/20
    tr_chan: '1'
    tr_delay: '0.002'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Incoming Bits"'
    size: '120'
    srate: '1'
    tr_tag: '"sync"'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Access triggered"'
    size: '120'
    srate: '1'
    tr_delay: '40'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"sync"'
    type: float
    ymin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: fff
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_eye_sink_x_1, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
