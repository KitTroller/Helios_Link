options:
  parameters:
    author: andreasodontopoulos
    generate_options: qt_gui
    id: Helios_ISM_Scanner_867MHz
    output_language: python
    title: Helios_ISM_Scanner_867MHz
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Centre Frequency (Hz)
    start: '863000000'
    step: '100000'
    stop: '870000000 '
    value: '868200000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '49'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    gui_hint: (1,0,1,1)
    type: complex
    update_time: '0.1'
    ymax: '-40'
    ymin: '-120'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    gui_hint: (0,0,1,1)
    int_max: '-40'
    int_min: '-120'
    type: complex
    update_time: '0.1'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
